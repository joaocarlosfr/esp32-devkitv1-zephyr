## boards/esp32_devkit_wroom/board.yml
```yaml
board:
  name: esp32_devkit1_wroom
  full_name: ESP32-DevKit1-WROOM
  vendor: espressif
  socs:
  - name: esp32
```
